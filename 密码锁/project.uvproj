# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ../../keil51/7-2 定时器时钟/: Delay.c Delay.h LCD1602.c LCD1602.h
    ../../keil51/6-2 矩阵键盘密码锁/: MatrixKey.c MatrixKey.h
